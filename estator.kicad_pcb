File: estator.kicad_pcb (KiCad board)
At the start: 6 copper layers, 0 parts

Commit message: ok
Routing:
- net (no net): vias 4 -> 51
Other:
- copper layers 6 -> 4
